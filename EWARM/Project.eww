<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADXL345_IIC_l431.ewp</path>
  </project>
  <batchBuild />
</workspace>
